# IAR project vcan_Kinetis.ewp, settings and files
configuration FX15_Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.hex
configuration FX15_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration DZ10_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: F:\车\恩智浦智能车比赛\CODE\car\FTM_PWM_示波器\Prj\IAR\config files\vcan_ROM_K60X512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DZ10_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/Inc/: ANGEL.h calculate_PWM.h codetab.h Filter_2.h IMU_IIC.h L3G4200.h Magn.h MK60_conf.h MK60_it.h MMA8451.h OLED_I2C.h PORT_cfg.h UserInterface.h
    ../../App/: calculate_PWM.c Filter_2.c IMU_IIC.c L3G4200.c Magn.c main.c MK60_conf.c MK60_it.c MMA8451.c OLED_I2C.c PID.c PID.h Scopeinterface.c Scopeinterface.h UserInterface.c
    ../../Chip/inc/kinetis/: MK60DZ10.h
    ../../Board/src/: VCAN_LED.C
  group Board
    ../../Board/src/: VCAN_key.c VCAN_MMA7455.c VCAN_NRF24L0.c
  group Chip
    ../../Chip/src/: calculate_TURN.c misc.c MK60_adc.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/inc/: calculate_TURN.h common.h MK60_adc.h
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group LIB/CMSIS
    ../../Lib/CMSIS/Inc/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
